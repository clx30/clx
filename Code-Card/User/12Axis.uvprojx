# Keil uVision project 12Axis.uvprojx, settings and files
target 12Axis (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\User\Objects\download.bin ..\User\Objects\App.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_USB_OTG_FS,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\LIB;..\APP
  memory RVCT4: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group LIB
    ../LIB/: Algorithm_ver_00_01_07.lib can_master.lib Axis12_V04.lib INTERLAYER_VER01_10_08.lib
  group APP
    ../APP/: AppInit.c bsp_config.c FSM.c InterLayer.c Logic.c main.c Reset.c Teach.c UserTool.c LogicNotUsed.c LogicTerm.c AxisConfig.c
  group Startup
    ./: startup_stm32f40_41xxx.s
