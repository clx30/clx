# Keil uVision project YD_KZJ.uvprojx, settings and files
target YDKZJ (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,ARM
  c include: ..\APP;..\APP\Tool;..\APP\Config;..\LIB;..\APP\Drv
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: AppInit.c FSM.c Logic.c main.c MainTask.c Reset.c Teach.c
  group APP.Drv
    ../APP/Drv/: Feed.c Weld.c
  group APP.Tool
    ../APP/Tool/: AxisMove.c UserTool.c
  group APP.Config
    ../APP/Config/: bsp_config.c InterLayer.c AxisConfig.c
  group LIB
    ../LIB/: Algorithm_ver_00_01_08.lib BspLibA8I24O24_V00_11_02.lib can_master.lib INTERLAYER_VER01_10_12.lib
  group Startup
    ./: startup_stm32f40_41xxx_iap.s
